require avr-libc.inc

DEFAULT_PREFERENCE = "-1"
